# Keil uVision project awtk_damo_ui.uvprojx, settings and files
target awtk_damo_ui flexspi_nor_debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.4
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: elcdif_rgb.out
  c flags: Optim=1 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: SKIP_SYSCLK_INIT, XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, CPU_MIMXRT1052DVL6B, APP_LCDIF_DATA_BUS=kELCDIF_DataBus16Bit, USE_GUI_MAIN,WITH_STB_IMAGE,WITH_BITMAP_RGB565,WITH_STB_FONT,WITH_BITMAP_BGRA,WITH_MINI_FONT,WITH_DYNAMIC_TR,HAS_AWTK_CONFIG
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186 
 --gnu
  c include: ../../../../../CMSIS/Include;../../../../../devices;..;../../..;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052;../../../../../devices/MIMXRT1052/utilities/io;../../../../../devices/MIMXRT1052/utilities/str;../../../../../devices/MIMXRT1052/utilities/log;../../../../../devices/MIMXRT1052/utilities;../../../../../devices/MIMXRT1052/xip;..\awtk-port;..\..\..\..\..\middleware\awtk\src;..\..\..\..\..\middleware\awtk\src\ext_widgets;..\..\..\..\..\middleware\awtk\3rd;..\..\..\..\..\middleware\awtk\3rd\agge;..\..\..\..\..\middleware\awtk\3rd\nanovg;..\..\..\..\..\middleware\awtk\3rd\nanovg\base;..\..\..\..\..\middleware\awtk\3rd\nanovg\agge;..\..\..\..\..\middleware\awtk\3rd\libunibreak
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  memory RVCT4: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052xxxxx_flexspi_nor_sdram.scf
  link misc: --remove 
--keep=*(.boot_hdr.ivt) 
--keep=*(.boot_hdr.boot_data) 
--keep=*(.boot_hdr.dcd_data) 
--keep=*(.boot_hdr.conf) 
--predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group source
    ../: elcdif_rgb.c fsl_ft5406_rt.c fsl_ft5406_rt.h
  group board
    ../: pin_mux.c pin_mux.h
  group board-src
    ../: board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MIMXRT1052/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_elcdif.c fsl_elcdif.h fsl_flexspi.c fsl_flexspi.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lpuart.c fsl_lpuart.h fsl_lpi2c.c fsl_lpi2c.h
  group startup
    ../../../../../devices/MIMXRT1052/arm/: startup_MIMXRT1052.s
    ../../../../../devices/MIMXRT1052/: system_MIMXRT1052.c system_MIMXRT1052.h
  group utilities
    ../../../../../devices/MIMXRT1052/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../devices/MIMXRT1052/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../devices/MIMXRT1052/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1052/utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
  group xip
    ../../../../../devices/MIMXRT1052/xip/: evkbimxrt1050_flexspi_nor_config.c evkbimxrt1050_flexspi_nor_config.h evkbimxrt1050_sdram_ini_dcd.c evkbimxrt1050_sdram_ini_dcd.h fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
  group awtk::demos
    ../../../../../middleware/awtk/demos/: demo_main.c demo_ui_app.c assets.c assets.h
  group awtk-port
    ../awtk-port/: main_loop_easyarm_rt1052_raw.c platform.c
  group awtk::src
    ../../../../../middleware/awtk/src/: awtk_global.c
  group awtk::src::base
    ../../../../../middleware/awtk/src/base/: assets_manager.c bitmap.c canvas.c children_layouter.c clip_board.c custom_props.c enums.c event_queue.c events.c font.c font_loader.c font_manager.c glyph_cache.c idle.c image_base.c image_loader.c image_manager.c input_device_status.c input_engine.c input_method.c layout.c lcd.c line_break.c locale_info.c main_loop.c rom_fs.c self_layouter.c style.c style_const.c style_factory.c suggest_words.c system_info.c theme.c timer.c ui_builder.c velocity.c vgcanvas.c widget.c widget_animator.c widget_animator_factory_null.c widget_animator_manager.c widget_factory.c widget_vtable.c window_animator.c window_base.c window_manager.c
  group awtk::src::blend
    ../../../../../middleware/awtk/src/blend/: blend_image_rgb565_bgr565.c fill_image_bgr565.c image_g2d.c rotate_image_bgr565.c soft_g2d.c blend_image_bgr565_bgr565.c blend_image_bgr565_bgra8888.c blend_image_bgr565_rgba8888.c blend_image_bgr888_bgr565.c blend_image_bgr888_bgra8888.c blend_image_bgr888_rgba8888.c blend_image_bgra8888_bgr565.c blend_image_bgra8888_bgra8888.c blend_image_bgra8888_rgba8888.c blend_image_rgb565_bgra8888.c blend_image_rgb565_rgba8888.c blend_image_rgba8888_bgr565.c blend_image_rgba8888_bgra8888.c blend_image_rgba8888_rgba8888.c fill_image_bgr888.c fill_image_bgra8888.c fill_image_rgb565.c fill_image_rgba8888.c rotate_image_bgr888.c rotate_image_bgra8888.c rotate_image_rgb565.c rotate_image_rgba8888.c
  group awtk::src::clip_board
    ../../../../../middleware/awtk/src/clip_board/: clip_board_default.c
  group awtk::src::designer_support
    ../../../../../middleware/awtk/src/designer_support/: style_mutable.c
  group awtk::src::ext_widgets
    ../../../../../middleware/awtk/src/ext_widgets/: ext_widgets.c
  group awtk::src::ext_widgets::canvas_widget
    ../../../../../middleware/awtk/src/ext_widgets/canvas_widget/: canvas_widget.c
  group awtk::src::ext_widgets::color_picker
    ../../../../../middleware/awtk/src/ext_widgets/color_picker/: color_component.c color_picker.c rgb_and_hsv.c
  group awtk::src::ext_widgets::gif_image
    ../../../../../middleware/awtk/src/ext_widgets/gif_image/: gif_image.c
  group awtk::src::ext_widgets::guage
    ../../../../../middleware/awtk/src/ext_widgets/guage/: guage.c guage_pointer.c
  group awtk::src::ext_widgets::image_animation
    ../../../../../middleware/awtk/src/ext_widgets/image_animation/: image_animation.c
  group awtk::src::ext_widgets::image_value
    ../../../../../middleware/awtk/src/ext_widgets/image_value/: image_value.c
  group awtk::src::ext_widgets::keyboard
    ../../../../../middleware/awtk/src/ext_widgets/keyboard/: candidates.c keyboard.c
  group awtk::src::ext_widgets::progress_circle
    ../../../../../middleware/awtk/src/ext_widgets/progress_circle/: progress_circle.c
  group awtk::src::ext_widgets::rich_text
    ../../../../../middleware/awtk/src/ext_widgets/rich_text/: rich_text.c rich_text_node.c rich_text_parser.c rich_text_render_node.c
  group awtk::src::ext_widgets::scroll_view
    ../../../../../middleware/awtk/src/ext_widgets/scroll_view/: list_item.c list_view.c list_view_h.c scroll_bar.c scroll_view.c
  group awtk::src::ext_widgets::slide_menu
    ../../../../../middleware/awtk/src/ext_widgets/slide_menu/: slide_menu.c
  group awtk::src::ext_widgets::slide_view
    ../../../../../middleware/awtk/src/ext_widgets/slide_view/: slide_view.c
  group awtk::src::ext_widgets::svg_image
    ../../../../../middleware/awtk/src/ext_widgets/svg_image/: svg_image.c
  group awtk::src::ext_widgets::switch
    ../../../../../middleware/awtk/src/ext_widgets/switch/: switch.c
  group awtk::src::ext_widgets::text_selector
    ../../../../../middleware/awtk/src/ext_widgets/text_selector/: text_selector.c
  group awtk::src::ext_widgets::time_clock
    ../../../../../middleware/awtk/src/ext_widgets/time_clock/: digit_clock.c time_clock.c
  group awtk::src::font_loader
    ../../../../../middleware/awtk/src/font_loader/: font_loader_bitmap.c font_loader_ft.c font_loader_stb.c
  group awtk::src::image_loader
    ../../../../../middleware/awtk/src/image_loader/: image_loader_stb.c
  group awtk::src::input_engines
    ../../../../../middleware/awtk/src/input_engines/: input_engine_null.c input_engine_pinyin.cpp
  group awtk::src::input_methods
    ../../../../../middleware/awtk/src/input_methods/: input_method_creator.c input_method_default.inc input_method_null.inc input_method_sdl.inc suggest_words.inc
  group awtk::src::layouters
    ../../../../../middleware/awtk/src/layouters/: children_layouter_default.c children_layouter_factory.c self_layouter_default.c self_layouter_factory.c
  group awtk::src::lcd
    ../../../../../middleware/awtk/src/lcd/: lcd_mem_bgr565.c
  group awtk::src::main_loop
    ../../../../../middleware/awtk/src/main_loop/: main_loop_simple.c
  group awtk::src::misc
    ../../../../../middleware/awtk/src/misc/: new.cpp
  group awtk::src::platforms::raw
    ../../../../../middleware/awtk/src/platforms/raw/: fs_os.c mutex_null.c sys_tick.c
  group awtk::src::svg
    ../../../../../middleware/awtk/src/svg/: bsvg.c bsvg_builder.c bsvg_draw.c bsvg_to_svg.c svg_path.c svg_path_parser.c svg_shape.c svg_to_bsvg.c
  group awtk::src::tkc
    ../../../../../middleware/awtk/src/tkc/: array.c buffer.c color.c color_parser.c date_time.c easing.c emitter.c fs.c func_call_parser.c matrix.c mem.c path.c rect.c str.c time_now.c tokenizer.c utf8.c utils.c value.c wstr.c
  group awtk::src::ui_loader
    ../../../../../middleware/awtk/src/ui_loader/: ui_binary_writer.c ui_builder_default.c ui_loader.c ui_loader_default.c ui_loader_xml.c ui_serializer.c ui_xml_writer.c window_open.c
  group awtk::src::vgcanvas
    ../../../../../middleware/awtk/src/vgcanvas/: vgcanvas_nanovg_soft.c
  group awtk::src::widget_animators
    ../../../../../middleware/awtk/src/widget_animators/: widget_animator_factory.c widget_animator_prop.c widget_animator_prop2.c widget_animator_scroll.c
  group awtk::src::widgets
    ../../../../../middleware/awtk/src/widgets/: app_bar.c button.c button_group.c calibration_win.c check_button.c color_tile.c column.c combo_box.c combo_box_item.c dialog.c dialog_client.c dialog_title.c dragger.c edit.c grid.c grid_item.c group_box.c image.c label.c pages.c popup.c progress_bar.c row.c slider.c spin_box.c system_bar.c tab_button.c tab_button_group.c tab_control.c view.c window.c
  group awtk::src::window_animators
    ../../../../../middleware/awtk/src/window_animators/: window_animator_fb.c window_animator_gpu.c window_animator_null.c
  group awtk::src::xml
    ../../../../../middleware/awtk/src/xml/: xml_builder.c xml_parser.c
  group awtk::3rd::nanovg::agg
    ../../../../../middleware/awtk/3rd/nanovg/agg/: nanovg_agg.cpp nanovg_agg.h nanovg_vertex.h
  group awtk::3rd::nanovg::base
    ../../../../../middleware/awtk/3rd/nanovg/base/: nanovg.c
  group awtk::3rd::agg
    ../../../../../middleware/awtk/3rd/agg/src/: agg_color_rgba.cpp agg_image_filters.cpp agg_sqrt_tables.cpp agg_trans_affine.cpp agg_vcgen_stroke.cpp
  group awtk::3rd::libunibreak
    ../../../../../middleware/awtk/3rd/libunibreak/: emojidef.c graphemebreak.c linebreak.c linebreakdata.c linebreakdef.c unibreakbase.c unibreakdef.c wordbreak.c
  group awtk::3rd::agge
    ../../../../../middleware/awtk/3rd/agge/agge/: math.cpp stroke.cpp stroke_features.cpp vector_rasterizer.cpp
  group awtk::3rd::nanovg::agge
    ../../../../../middleware/awtk/3rd/nanovg/agge/: nanovg_agge.cpp nanovg_vertex.cpp
