# Keil uVision project awtk_gui_demo.uvprojx, settings and files
target awtk_gui_demo flexspi_nor_sdram_debug (5060020::V5.06 (build 20)::ARMCC)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.4
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: awtk_gui_demo.out
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, SKIP_SYSCLK_INIT, DEBUG, CPU_MIMXRT1052DVL6B, HAS_AWTK_CONFIG, LCD_W=480
  c misc: --library_interface=armcc --diag_suppress=66,1296,186 --diag_suppress=1296,186 --gnu
  c include: ..;../../..;../../../../../CMSIS/Include;../../../../../devices;../../../../../middleware/emwin/emWin_Config;../../../../../middleware/emwin/emWin_header;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/drivers;../../../../../components/ft5406_rt;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052;../../../../../devices/MIMXRT1052/utilities/str;../../../../../devices/MIMXRT1052/utilities/debug_console;../../../../../components/uart;../../../../../components/serial_manager;../../../../../components/serial_manager;../../../../../devices/MIMXRT1052/drivers;../../../../../components/lists;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/xip;../../../xip;..\..\..\..\..\middleware\awtk\src;..\..\..\..\..\middleware\awtk\src\ext_widgets;..\..\..\..\..\middleware\awtk-rt1052-raw\awtk-port
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052xxxxx_flexspi_nor_sdram.scf
  link misc: --remove --keep=*(.boot_hdr.ivt) --keep=*(.boot_hdr.boot_data) --keep=*(.boot_hdr.dcd_data) --keep=*(.boot_hdr.conf) --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group source
    ../: awtk_gui_demo.c
  group board
    ../: pin_mux.c pin_mux.h emwin_support.c emwin_support.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MIMXRT1052/drivers/: fsl_elcdif.c fsl_elcdif.h fsl_pxp.c fsl_pxp.h fsl_lpi2c.c fsl_lpi2c.h fsl_common.c fsl_common.h fsl_clock.c fsl_clock.h fsl_lpuart.c fsl_lpuart.h fsl_iomuxc.h fsl_gpio.c fsl_gpio.h
  group touchpanel
    ../../../../../components/ft5406_rt/: fsl_ft5406_rt.c fsl_ft5406_rt.h
  group device
    ../../../../../devices/MIMXRT1052/: MIMXRT1052.h MIMXRT1052_features.h fsl_device_registers.h system_MIMXRT1052.c system_MIMXRT1052.h
  group utilities
    ../../../../../devices/MIMXRT1052/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1052/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1052/utilities/: fsl_assert.c
  group component-uart
    ../../../../../components/uart/: lpuart_adapter.c uart.h
  group component-serial_manager
    ../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component-lists
    ../../../../../components/lists/: generic_list.c generic_list.h
  group startup
    ../../../../../devices/MIMXRT1052/arm/: startup_MIMXRT1052.s
  group xip
    ../../../../../devices/MIMXRT1052/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
    ../../../xip/: evkbimxrt1050_flexspi_nor_config.c evkbimxrt1050_flexspi_nor_config.h evkbimxrt1050_sdram_ini_dcd.c evkbimxrt1050_sdram_ini_dcd.h
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm7.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h mpu_armv7.h mpu_armv8.h
  group awtk-port
    ../../../../../middleware/awtk-rt1052-raw/awtk-port/: fs_os.c main_loop_easyarm_rt1052_raw.c mutex_null.c platform.c
  group Chart-Demo
    ../../../../../middleware/awtk-examples/Chart-Demo/src/: app_main.c window_bar_series.c window_line_series.c window_main.c window_meter.c window_pie.c window_series_common.c
    ../../../../../middleware/awtk-examples/Chart-Demo/src/custom_widgets/: custom_widgets.c
    ../../../../../middleware/awtk-examples/Chart-Demo/src/custom_widgets/base/: fifo.c
    ../../../../../middleware/awtk-examples/Chart-Demo/src/custom_widgets/chart/: axis.c axis_p.c bar_series.c chart_animator.c chart_utils.c chart_view.c line_series.c series.c series_p.c tooltip.c x_axis.c y_axis.c
    ../../../../../middleware/awtk-examples/Chart-Demo/src/custom_widgets/pie_slice/: pie_slice.c
  group LIBS
    ../../../../../middleware/awtk-rt1052-raw/lib/: awtk_imx1050.lib
